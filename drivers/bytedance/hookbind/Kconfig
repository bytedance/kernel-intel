## drivers/bytedance/hookbind/Kconfig
```kconfig
#
# Bytedance module configuration
#
config BYTEDANCE_HOOKBIND
	tristate "bytedance hook bind module"
	---help---
	  this module is hook bind 
```
